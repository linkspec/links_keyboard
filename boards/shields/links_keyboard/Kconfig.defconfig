## boards/shields/links_keyboard/Kconfig.shield
```kconfig
config SHIELD_LINKS_KEYBOARD
    def_bool $(shields_list_contains,links_keyboard)
```
